# Keil uVision project Therm.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Therm +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Src
    ./Core/Src/: adc.c main.c pwm.c
  group Inc
    ./Core/Inc/: adc.h pwm.h
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS:CORE 6.2.0, CMSIS:NN Lib 7.0.0, Device:GPIO 1.3, Device:Startup 1.0.0
